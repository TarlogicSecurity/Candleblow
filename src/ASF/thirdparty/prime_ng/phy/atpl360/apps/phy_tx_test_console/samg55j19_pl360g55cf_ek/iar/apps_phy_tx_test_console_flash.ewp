# IAR project apps_phy_tx_test_console_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMG55J19 Atmel SAMG55J19
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: __SAMG55J19__; __ATPL360B__; UDD_ENABLE; BOARD=PL360G55CF_EK; __FREERTOS__; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\..\sam\drivers\spi; ..\..\..\..\..\..\..\..\sam\utils\fpu; ..\..\..\..\..\..\..\..\common\services\ioport; ..\..\..\..\..\..\..\..\common\services\usb\class\cdc\device; ..\..\..\..\..\..\..\..\sam\utils\cmsis\samg\samg55\include; ..\..\..\..\..\..\..\..\sam\utils; ..\..; ..\..\..\..\..\..\..\..\sam\drivers\udp; ..\..\..\..\..\..\..\..\common\boards; ..\..\..\..\..\..\..\..\sam\drivers\wdt; ..\..\..\..\..\..\..\..\common\services\usb\udc; ..\..\..\..\..\..\..\..\common\components\plc\atpl360; ..\..\..\..\..\..\..\..\sam\drivers\pdc; ..\..\..\..\..\..\..\..\sam\boards; ..\..\..\..\..\..\..\..\sam\drivers\rstc\example1; ..\..\..\..\..\..\..\..\sam\drivers\pmc; ..\..\..\..\..\..\..\..\sam\boards\pl360g55cf_ek; ..\..\..\..\..\..\..\..\sam\utils\cmsis\samg\samg55\source\templates; ..\..\..\..\..\..\..\..\sam\utils\preprocessor; ..\..\..\..\..\..\..\..\sam\drivers\gpbr; ..\..\..\..\..\..\..\..\common\utils; ..\..\..\..\..\..\..\..\common\services\delay; ..\..\..\..\..\..\..\..\common\services\usb\class\cdc; ..\..\..\..\..\..\..\..\sam\drivers\pio; ..; ..\..\..\..\..\..\..\..\sam\drivers\tc; ..\..\..\..\..\..\..\..\common\components\plc\atpl360\PRIME; ..\..\..\..\..\..\..\freertos\freertos-7.3.0\source\include; ..\..\..\..\..\..\..\..\sam\drivers\supc; ..\..\..\..\..\..\..\..\common\services\clock; ..\..\..\..\..\..\..\..\sam\drivers\flexcom; ..\..\..\..\..\..\hal; ..\..\..\..\..\..\..\freertos\freertos-7.3.0\source\portable\iar\sam_cm4f; ..\..\..\..\..\..\..\..\common\services\usb; ..\..\..\..\..\..\..\..\common\services\gpio; ..\..\..\..\..\..\..\..\sam\drivers\efc; ..\..\..\..\..\..\..\..\sam\drivers\matrix; ..\..\..\..\..\..\..\..\sam\utils\header_files; ..\..\..\..\..\..\..\..\common\services\serial\sam_uart; ..\..\..\..\..\..\..\..\common\components\plc\atpl360\addons\serial_if; ..\..\..\..\..\..\..\..\common\services\serial; ..\..\..\..\..\..\..\..\sam\drivers\pdc\pdc_uart_example; ..\..\..\..\..\..\..\..\common\utils\stdio\stdio_serial; ..\..\..\..\..\..\..\..\sam\drivers\usart; ..\..\..\..\..\..\..\..\sam\services\flash_efc; ..\..\..\..\..\..\..\..\common\services\sleepmgr; ..\..\..\..\..\..\..\..\common\components\plc\atpl360\addons; ..\..\..\..\..\..\..\..\sam\drivers\rstc; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apps_phy_tx_test_console_flash.bin
  ILINK.IlinkOutputFile: apps_phy_tx_test_console_flash.out
  ILINK.IlinkIcfFile: ..\..\..\linker_scripts\iar\samg55_flash_isp.icf
  ILINK.IlinkExtraOptions: --image_input ..\..\..\..\..\..\..\..\atpl\bin\ATPL360B_PRIME.bin,atpl_bin,P_atpl_bin,8; --keep atpl_bin
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/prime_ng/hal
    ../../../../../../hal/: hal_timer.c hal_plc.c hal_usi.c hal_aes.c hal_usart.c hal_pib.c hal_usb.c hal_reset_handler.c hal.c hal_pcrc.c hal_uart.c hal_trng.c hal_fu.c hal_cfg.c hal_net_freq_dummy.c hal_null_dev.c hal_private.h hal_regions.h hal.h
  group thirdparty/prime_ng/phy/atpl360/apps/phy_tx_test_console
    ../../: phy_embedded_app.c phy_tx_test_console.c phy_embedded_app.h
  group thirdparty/prime_ng/phy/atpl360/apps/phy_tx_test_console/samg55j19_pl360g55cf_ek
    ../: conf_app_example.h conf_clock.h conf_usb.h conf_sleepmgr.h conf_uart_serial.h conf_board.h FreeRTOSConfig.h conf_hal.h conf_atpl360.h conf_usi.h
  group thirdparty/prime_ng/phy/atpl360/apps/phy_tx_test_console/samg55j19_pl360g55cf_ek/iar
    ./: asf.h
  group thirdparty/freertos/freertos-7.3.0/source
    ../../../../../../../freertos/freertos-7.3.0/source/: FreeRTOS_CLI.c queue.c list.c timers.c tasks.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/iar/sam_cm4f
    ../../../../../../../freertos/freertos-7.3.0/source/portable/iar/sam_cm4f/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-7.3.0/source/portable/memmang
    ../../../../../../../freertos/freertos-7.3.0/source/portable/memmang/: heap_4.c
  group thirdparty/freertos/freertos-7.3.0/source/include
    ../../../../../../../freertos/freertos-7.3.0/source/include/: list.h portable.h queue.h projdefs.h FreeRTOS.h FreeRTOS_CLI.h mpu_wrappers.h semphr.h timers.h croutine.h task.h StackMacros.h
  group common/components/plc/atpl360
    ../../../../../../../../common/components/plc/atpl360/: atpl360_boot.c atpl360_IB.c atpl360.c atpl360_hal_spi.c atpl360_IB.h atpl360_boot.h atpl360_hal_spi.h atpl360.h atpl360_IB_db_api.h atpl360_exception.h
  group common/components/plc/atpl360/PRIME
    ../../../../../../../../common/components/plc/atpl360/PRIME/: atpl360_comm.c atpl360_IB_db.c atpl360_IB_db.h atpl360_comm.h general_defs.h
  group common/components/plc/atpl360/addons
    ../../../../../../../../common/components/plc/atpl360/addons/: addon_api.h
  group common/components/plc/atpl360/addons/serial_if
    ../../../../../../../../common/components/plc/atpl360/addons/serial_if/: serial_if_prime.c serial_if.c serial_if.h
  group common/services/usb
    ../../../../../../../../common/services/usb/: usb_atmel.h usb_protocol.h
  group common/services/usb/class/cdc
    ../../../../../../../../common/services/usb/class/cdc/: usb_protocol_cdc.h
  group common/services/usb/class/cdc/device
    ../../../../../../../../common/services/usb/class/cdc/device/: udi_cdc.c udi_cdc_desc.c udi_cdc_conf.h udi_cdc.h
  group common/services/usb/udc
    ../../../../../../../../common/services/usb/udc/: udc.c udc_desc.h udc.h udi.h udd.h
  group common/services/sleepmgr
    ../../../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/clock
    ../../../../../../../../common/services/clock/: sysclk.h pll.h genclk.h osc.h
  group common/services/clock/samg
    ../../../../../../../../common/services/clock/samg/: sysclk.c osc.h sysclk.h pll.h genclk.h
  group common/services/serial
    ../../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/delay
    ../../../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/gpio
    ../../../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
  group sam/drivers/wdt
    ../../../../../../../../sam/drivers/wdt/: wdt.c wdt.h
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pdc
    ../../../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/pdc/pdc_uart_example
    ../../../../../../../../sam/drivers/pdc/pdc_uart_example/: pdc_uart_example.h
  group sam/drivers/matrix
    ../../../../../../../../sam/drivers/matrix/: matrix.c matrix.h
  group sam/drivers/tc
    ../../../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/pio
    ../../../../../../../../sam/drivers/pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/efc
    ../../../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/flexcom
    ../../../../../../../../sam/drivers/flexcom/: flexcom.c flexcom.h
  group sam/drivers/spi
    ../../../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/supc
    ../../../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/drivers/pmc
    ../../../../../../../../sam/drivers/pmc/: sleep.c pmc.c pmc.h sleep.h
  group sam/drivers/gpbr
    ../../../../../../../../sam/drivers/gpbr/: gpbr.c gpbr.h
  group sam/drivers/udp
    ../../../../../../../../sam/drivers/udp/: udp_device.c udp_device.h
  group sam/drivers/rstc
    ../../../../../../../../sam/drivers/rstc/: rstc.c rstc.h
  group sam/drivers/rstc/example1
    ../../../../../../../../sam/drivers/rstc/example1/: rstc_example1.h
  group sam/boards/pl360g55cf_ek
    ../../../../../../../../sam/boards/pl360g55cf_ek/: init.c pl360g55cf_ek.h led.h
  group sam/utils
    ../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/samg/samg55/source/templates
    ../../../../../../../../sam/utils/cmsis/samg/samg55/source/templates/: system_samg55.c
  group sam/utils/cmsis/samg/samg55/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/samg/samg55/source/templates/iar/: startup_samg55.c
  group sam/utils/cmsis/samg/samg55/include
    ../../../../../../../../sam/utils/cmsis/samg/samg55/include/: samg55j18.h samg55g18.h samg55g19.h samg55n19.h samg55.h system_samg55.h samg55j19.h
  group sam/utils/cmsis/samg/samg55/include/instance
    ../../../../../../../../sam/utils/cmsis/samg/samg55/include/instance/: twi3.h cmcc.h twi5.h pdmic1.h usart2.h usart0.h flexcom1.h udp.h usart7.h flexcom3.h wdt.h twi7.h supc.h usart5.h usart3.h uhp.h i2sc0.h usart1.h piob.h spi5.h spi3.h efc.h tc0.h flexcom7.h mem2mem.h matrix.h rtt.h flexcom5.h crccu.h twi6.h rstc.h spi1.h twi1.h spi6.h pmc.h i2sc1.h spi7.h chipid.h spi4.h flexcom0.h flexcom6.h tc1.h flexcom4.h spi0.h twi2.h twi0.h pioa.h pdmic0.h spi2.h adc.h rtc.h usart6.h usart4.h gpbr.h flexcom2.h twi4.h
  group sam/utils/cmsis/samg/samg55/include/pio
    ../../../../../../../../sam/utils/cmsis/samg/samg55/include/pio/: samg55g19.h samg55n19.h samg55j19.h samg55g18.h samg55j18.h
  group sam/utils/cmsis/samg/samg55/include/component
    ../../../../../../../../sam/utils/cmsis/samg/samg55/include/component/: uhp.h rtc.h pmc.h pio.h supc.h matrix.h efc.h cmcc.h flexcom.h adc.h rstc.h i2sc.h pdmic.h mem2mem.h pdc.h udp.h gpbr.h usart.h spi.h chipid.h rtt.h twi.h crccu.h tc.h wdt.h
  group sam/utils/fpu
    ../../../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/header_files
    ../../../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../../../sam/utils/preprocessor/: stringz.h preprocessor.h mrepeat.h tpaste.h
  group sam/services/flash_efc
    ../../../../../../../../sam/services/flash_efc/: flash_efc.c flash_efc.h
